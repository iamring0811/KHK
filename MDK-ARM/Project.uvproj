# Keil uVision project Project.uvproj, settings and files
target STM32F429_439xx (ARM-ADS)
  device: STM32F439II STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: DF6-V100 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM324x9I_EVAL,USE_USB_OTG_HS,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM324x9I_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group User
    ../: main.c RESM.C touch.c dsp.c Meas.c sysadj.c COM.C data.c
    ../USB/: usbh_hid_usr.c usbh_msc_usr.c
  group Util
    ../Util/: tm_adc.c usart.c Flash.C eep.c LCD.C para.c
  group Common
    ../Common/: system_stm32f4xx.c stm324x9i_eval.c stm32f4xx_it.c stm32f4xx_flash.c 32f429_sdram.c 32f429_lcd.c 32f429_port.c fsmc_nand.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_cryp.c stm32f4xx_cryp_des.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_hash.c stm32f4xx_hash_sha1.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_sai.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_adc.c stm32f4xx_cryp_aes.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_usart.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_hash_md5.c stm32f4xx_rtc.c stm32f4xx_cryp_tdes.c stm32f4xx_ltdc.c stm32f4xx_syscfg.c stm32f4xx_fmc.c
  group USB
    ../USB/USBLib/: usb_bsp.c usb_core.c usb_hcd.c usb_hcd_int.c usbh_core.c usbh_hcs.c usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_ioreq.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c usbh_stdreq.c
    ../USB/FATLib/: ff.c
    ../USB/: USB_FILE.c USB.c
